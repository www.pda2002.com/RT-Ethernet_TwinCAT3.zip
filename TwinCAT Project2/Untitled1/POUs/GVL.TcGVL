{attribute 'qualified_only'}
VAR_GLOBAL
	PDA AT %Q*:TPDA;
	W1 AT %Q*:WORD;
END_VAR
