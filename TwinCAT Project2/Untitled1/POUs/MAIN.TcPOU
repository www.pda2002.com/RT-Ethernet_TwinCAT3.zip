PROGRAM MAIN
VAR
	aaa:TPDA;
END_VAR

GVL.W1:=GVL.W1+1;
GVL.PDA.pdaInt[0]:=GVL.PDA.pdaInt[0]+1;

END_PROGRAM
